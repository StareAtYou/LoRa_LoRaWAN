# Keil uVision project STM32L1_Project.uvprojx, settings and files
target UART (ARM-ADS)
  device: STM32L151C8 STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00002800) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1_Project +hex
  c flags: Optim=1
  c include: ..\Driver;..\main;..\STM32L1xx_StdPeriph_Driver\inc;..\STM32L1xx_StdPeriph_Driver\src;..\Driver\enc28j60;..\Driver\led;..\Driver\net;..\Driver\spi;..\Driver\adc;..\Driver\temp;..\Driver\system\delay;..\Driver\system\sys;..\System;..\Driver\usart1;..\Driver\bsp;..\Driver\usart3;..\Driver\usart2;..\Driver\key;..\Driver\lora;..\Driver\gps;..\Driver\timer;..\Driver\bluetooth;..\Driver\oled
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2800
  group startup
    ./: startup_stm32l1xx_md.s
  group stm32l_lib
    ../STM32L1xx_StdPeriph_Driver/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group main
    ../main/: main.c system_stm32l1xx.c stm32l1xx_it.c
  group sys
    ../Driver/system/delay/: delay.c
    ../Driver/system/sys/: sys.c
  group bsp
    ../Driver/led/: led.c
    ../Driver/bsp/: bsp.c
    ../Driver/usart1/: usart1.c
    ../Driver/usart2/: usart2.c
    ../Driver/usart3/: usart3.c
    ../Driver/key/: key.c
    ../Driver/lora/: lora.c
    ../Driver/gps/: gps.c
    ../Driver/timer/: timer.c
    ../Driver/oled/: oled.c
    ../Driver/bluetooth/: bluetooth.c
